# Keil uVision project 任务.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 任务 +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\fwlib\inc;..\user;..\hardware\TIMER;..\delay
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c
  group core
    ../core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group hardware
    ../hardware/TIMER/: pwm.c
  group fwlib
    ../fwlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group delay
    ../delay/: delay.c
